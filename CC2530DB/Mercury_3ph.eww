<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Mercury_3ph.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>Mercury_3ph</project>
                <configuration>Mercury_3ph_EndDevice</configuration>
            </member>
            <member>
                <project>Mercury_3ph</project>
                <configuration>Mercury_3ph_Router</configuration>
            </member>
            <member>
                <project>Mercury_3ph</project>
                <configuration>Mercury_3ph_Router_CC2592</configuration>
            </member>
            <member>
                <project>Mercury_3ph</project>
                <configuration>Mercury_3ph_EndDevice_CC2592</configuration>
            </member>
            <member>
                <project>Mercury_3ph</project>
                <configuration>Mercury_3ph_EndDevice_CC2591</configuration>
            </member>
            <member>
                <project>Mercury_3ph</project>
                <configuration>Mercury_3ph_Router_CC2591</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
